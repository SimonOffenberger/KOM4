# Keil uVision project KOM4.uvprojx, settings and files
target APUS (6220000::V6.22::ARMCLANG)
  device: STM32F072VBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: .\;..\..\system\cmsis;..\..\system\stm32f0-stdperiph;..\..\system\board;..\..\system\utils;..\..\system\board;..\..\system\proj\3Bit CNT;..\..\system\proj\Alarm;..\..\system\proj\LEDTimer;..\..\system\proj\INT;..\..\system\proj\UART_VCOM;..\..\system\proj\UART_DMA;..\..\system\proj\ADC_TEMP_SENS;..\..\system\proj\I2C_Temp;..\..\system\modules\ADC;..\..\system\modules\Button;..\..\system\modules\CriticalSection;..\..\system\modules\EventQueue;..\..\system\modules\Fonts;..\..\system\modules\GPIO;..\..\system\modules\Images;..\..\system\modules\Lcd;..\..\system\modules\Led;..\..\system\modules\SoftKeys;..\..\system\modules\StateMachine;..\..\system\modules\States;..\..\system\modules\TIMER;..\..\system\modules\TSC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group stm32f0-stdperiph
    ../../system/stm32f0-stdperiph/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_syscfg.c stm32f0xx_exti.c stm32f0xx_dma.c stm32f0xx_adc.c stm32f0xx_i2c.c
  group cmsis
    ../../system/cmsis/: system_stm32f0xx.c startup_stm32f072.s
  group app
    ./: stm32f0xx_conf.h main.c
    ../../system/proj/3Bit CNT/: 3bit_cnt.c
    ../../system/proj/Alarm/: alarm.c
    ../../system/proj/LEDTimer/: LedTimer.c
    ../../system/proj/INT/: Interrupt_Proj.c
    ../../system/proj/UART_VCOM/: Uart_Vcom.c
    ../../system/proj/UART_DMA/: Uart_DMA.c
    ../../system/proj/ADC_TEMP_SENS/: ADC_Temp_prj.c
    ../../system/proj/I2C_Temp/: i2c_temp.c
  group utils
    ../../system/utils/: sysdelay.c
  group board
    ../../system/board/: board_button.c board_led.c rgb_timer.c board_uart.c board_uart_dma.c board_adc.c i2c.c board_MCP_temp.c
  group modules
    ../../system/modules/Lcd/: Lcd.c
    ../../system/modules/Images/: Image.c MonochromeImage.c
    ../../system/modules/Fonts/: Consolas.c
    ../../system/modules/TSC/: tsc.c
    ../../system/modules/GPIO/: Gpio.c
